# IAR project dpp-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cm\qxk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-l152re
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qxk.out
  ILINK.IlinkIcfFile: dpp-qxk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xE ST STM32L152xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; QF_ON_CONTEXT_SW
  group Application
    ../: bsp.c xthread1.c xthread2.c
    ../../: bsp.h app.h main.c philo.c table.c
  group nucleo-l152re
    ../../../../../3rd_party/nucleo-l152re/iar/: startup_stm32l1xx.s
    ../../../../../3rd_party/nucleo-l152re/: stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qxk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c qstamp.c
