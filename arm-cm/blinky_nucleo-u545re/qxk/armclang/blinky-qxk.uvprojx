# Keil uVision project blinky-qxk.uvprojx, settings and files
target blinky-dbg (6220000::V6.22::ARMCLANG)
  device: STM32U545RETxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x28000000,0x00004000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: blinky-qxk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky-qxk.bin .\dbg\blinky-qxk.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32U545xx
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qxk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-u545re
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x28000000 size 0x4000
  scatter file: .\blinky-qxk.sct
  link misc: --entry Reset_Handler
  group Source Code
    ../../: app.h bsp.h blinky.c main.c qp_config.h
    ../: bsp.c xthr.c
  group nucleo-u545re
    ../../../../../3rd_party/nucleo-u545re/: stm32u5xx.h stm32u545xx.h system_stm32u5xx.c system_stm32u5xx.h
    ../../../../../3rd_party/nucleo-u545re/arm/: startup_stm32u545retxq.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/armclang/: qs_port.h qxk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c
target blinky-rel (6220000::V6.22::ARMCLANG)
  device: STM32U545RETxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: as above
  output: blinky-qxk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\blinky-qxk.bin .\rel\blinky-qxk.axf
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG,STM32U545xx
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x28000000 size 0x4000
  scatter file: .\blinky-qxk.sct
  link misc: --entry Reset_Handler
target blinky-spy (6220000::V6.22::ARMCLANG)
  device: STM32U545RETxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: as above
  output: blinky-qxk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\blinky-qxk.bin .\spy\blinky-qxk.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY,STM32U545xx
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x28000000 size 0x4000
  scatter file: .\blinky-qxk.sct
  link misc: --entry Reset_Handler
