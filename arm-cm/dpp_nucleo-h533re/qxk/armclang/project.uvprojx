# Keil uVision project project.uvprojx, settings and files
target dbg (6230000::V6.23::ARMCLANG)
  device: STM32H533RETx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x30000000,0x00020000) IROM(0x08000000,0x0080000) IROM2(0x0C000000,0x0080000) XRAM(0x20020000,0x00014000) XRAM2(0x30020000,0x00014000) XRAM3(0x20034000,0x00010000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: project
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\project.bin .\dbg\project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H533xx
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qxk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-h533re
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT6: RAM 0x20020000 size 0x14000
  memory RVCT7: RAM 0x30020000 size 0x14000
  memory RVCT8: RAM 0x20034000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
  group Source Code
    ../../: app.h bsp.h main.c qp_config.h philo.c table.c
    ../: bsp.c xthread1.c xthread2.c
  group nucleo-h533re
    ../../../../../3rd_party/nucleo-h533re/: stm32h5xx.h stm32h533xx.h system_stm32h5xx.c system_stm32h5xx.h
    ../../../../../3rd_party/nucleo-h533re/arm/: startup_stm32h533retx.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/armclang/: qs_port.h qxk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c
target rel (6230000::V6.23::ARMCLANG)
  device: STM32H533RETx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.2.0
  cpu: as above
  output: project
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\project.bin .\rel\project.axf
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: NDEBUG,STM32H533xx
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT6: RAM 0x20020000 size 0x14000
  memory RVCT7: RAM 0x30020000 size 0x14000
  memory RVCT8: RAM 0x20034000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
target spy (6230000::V6.23::ARMCLANG)
  device: STM32H533RETx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.2.0
  cpu: as above
  output: project
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\project.bin .\spy\project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY,STM32H533xx
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT6: RAM 0x20020000 size 0x14000
  memory RVCT7: RAM 0x30020000 size 0x14000
  memory RVCT8: RAM 0x20034000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
