# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575RG ST STM32U575RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32H533xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ../..; ../../../../../include; ../../../../../ports/arm-cm/qxk/iar; ../../../../../3rd_party/CMSIS/Include; ../../../../../3rd_party/nucleo-h533re
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: project.bin
  prebuild: cmd /c "if exist $OBJ_DIR$/qstamp.o del $OBJ_DIR$/qstamp.o"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32H533xx
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STM32H533xx
  group (top)
    ./: README.txt
  group Application
    ../../: app.h bsp.h main.c philo.c qp_config.h table.c
    ../: bsp.c xthread1.c xthread2.c
  group nucleo-h533re
    ../../../../../3rd_party/nucleo-h533re/iar/: startup_stm32h533retx.s
    ../../../../../3rd_party/nucleo-h533re/: stm32h533xx.h stm32h5xx.h system_stm32h5xx.c system_stm32h5xx.h
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qp_port.h qs_port.h qxk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c qstamp.c
