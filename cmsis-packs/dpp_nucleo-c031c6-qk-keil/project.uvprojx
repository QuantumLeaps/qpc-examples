# Keil uVision project project.uvprojx, settings and files
target dbg (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: QP_CONFIG
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\project.sct
  group Application
    ./: bsp.c bsp.h dpp.h main.c philo.c table.c
target spy (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: Q_SPY,QP_CONFIG
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\project.sct
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, RTEF:Event Processor 7.3.4, RTEF:Framework 7.3.4, RTEF:Real-Time Kernel 7.3.4, RTEF:Software tracing 7.3.4
