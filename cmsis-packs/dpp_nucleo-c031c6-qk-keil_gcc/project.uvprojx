# Keil uVision project project.uvprojx, settings and files
target dbg (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: objcopy --input-target=ihex --output-target=binary !H $H@P.bin
  group Application
    ./: bsp.c bsp.h dpp.h main.c philo.c table.c startup_stm32c031xx.c system_stm32c0xx.c
target spy (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: project +hex
  AfterMake: as above
target rel (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: project +hex
  AfterMake: as above
software components: CMSIS:CORE 5.6.0, RTEF:Event Processor 7.3.4, RTEF:Framework 7.3.4, RTEF:Real-Time Kernel 7.3.4, RTEF:Software tracing 7.3.4
