# Keil uVision project test_nucleo-u545.uvprojx, settings and files
target test_nucleo-u545 (6220000::V6.22::ARMCLANG)
  device: STM32U545RETxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x28000000,0x00004000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: test_nucleo-u545
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\test_nucleo-u545.bin .\dbg\test_nucleo-u545.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY,Q_UTEST,STM32U545xx
  c include: .;..\src;..\..\..\..\include;..\..\..\..\src;..\..\..\..\ports\arm-cm\qutest;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-u545re
  asm define: Stack_Size=2048,Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x28000000 size 0x4000
  link misc: --entry Reset_Handler
  group Application
    ./: test_blinky.c
    ../src/: blinky.c blinky.h bsp.c bsp.h
  group nucleo-u545re
    ../../../../../3rd_party/nucleo-u545re/: stm32u5xx.h stm32u545xx.h system_stm32u5xx.c system_stm32u5xx.h
    ../../../../../3rd_party/nucleo-u545re/arm/: startup_stm32u545retxq.s
  group QP
    ../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c qutest.c
  group QP_port
    ../../../../3rd_party/nucleo-u545re/qutest/: qutest_port.c
