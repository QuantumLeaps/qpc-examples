# Keil uVision project test_tm4c123-arm.uvprojx, settings and files
target test_tm4c123-arm (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_tm4c123-arm
  BeforeMake: cmd /c "del .\dbg_armclang\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg_armclang\test_tm4c123-arm.bin .\dbg_armclang\test_tm4c123-arm.axf
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: Q_SPY Q_UTEST
  c include: .;..\src;..\..\..\..\include;..\..\..\..\src;..\..\..\..\ports\arm-cm\qutest;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=2048 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../../../../src/qs/: qstamp.c
    ./: test_self.c
  group ek-tm4c123gxl
    ../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
    ../../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group QP
    ../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qutest.c
  group QP_port
    ../../../../3rd_party/ek-tm4c123gxl/qutest/: qutest_port.c
