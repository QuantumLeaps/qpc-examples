# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575RG ST STM32U575RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32U545xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\ports\uc-os2; ..\..\..\..\..\3rd_party\uC-OS2\Source; ..\..\..\..\..\3rd_party\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-u545re
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32U545xx
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STM32U545xx
  group Application
    ../: app_cfg.h bsp.c bsp.h app.h main.c os_cfg.h philo.c qp_config.h table.c
  group nucleo-u545re
    ../../../../../3rd_party/nucleo-u545re/iar/: startup_stm32u545retxq.s
    ../../../../../3rd_party/nucleo-u545re/: stm32u545xx.h stm32u5xx.h system_stm32u5xx.c system_stm32u5xx.h
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    ../../../../../ports/uc-os2/: qf_port.c qp_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c qstamp.c
  group uC-OS2
    ../../../../../3rd_party/uC-OS2/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC-OS2_port
    ../../../../../3rd_party/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm os_dbg.c
    ../../../../../3rd_party/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
