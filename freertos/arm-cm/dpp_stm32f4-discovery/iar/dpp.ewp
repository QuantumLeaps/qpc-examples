# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\ports\freertos; ..\..\..\..\..\3rd_party\FreeRTOS-Kernel\include; ..\..\..\..\..\3rd_party\FreeRTOS-Kernel\portable\IAR\ARM_CM4F; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\stm32f4-discovery; ..\..\..\..\..\3rd_party\stm32f4-discovery\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group Application
    ../: bsp.c bsp.h app.h FreeRTOSConfig.h main.c philo.c qp_config.h table.c
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS-Kernel/: list.c queue.c tasks.c
    ../../../../../3rd_party/FreeRTOS-Kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    ../../../../../ports/freertos/: qf_port.c qp_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_rx.c qstamp.c
  group stm32f4-discovery
    ../../../../../3rd_party/stm32f4-discovery/iar/: startup_stm32f4xx.s
    ../../../../../3rd_party/stm32f4-discovery/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    ../../../../../3rd_party/stm32f4-discovery/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
